# Keil uVision project 二轮考核.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 二轮考核 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HANDWARE\Key;..\HANDWARE\LED;..\HANDWARE\OLED;..\HANDWARE\TIMER;..\HANDWARE\HCSR_04;..\HANDWARE\TIMEConuter;..\HANDWARE\reverse_timecounter;..\HANDWARE\ADC;..\HANDWARE\EXTI_MODE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c stm32f4xx_it.c main.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group HANDWARE
    ../HANDWARE/HCSR_04/: HCSR_04.c
    ../HANDWARE/Key/: key.c
    ../HANDWARE/LED/: led.c
    ../HANDWARE/OLED/: oled.c
    ../HANDWARE/TIMER/: timer.c
    ../HANDWARE/ADC/: adc.c
    ../HANDWARE/TIMEConuter/: timecount.c
    ../HANDWARE/reverse_timecounter/: reverse_timecounter.c
    ../HANDWARE/EXTI_MODE/: exti_mode.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
